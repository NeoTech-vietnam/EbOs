## test/on_target/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_UNICORE=n
CONFIG_FREERTOS_HZ=100
CONFIG_ESP_MAIN_TASK_STACK_SIZE=4096
CONFIG_COMPILER_OPTIMIZATION_ASSERTIONS_ENABLE=y
```
